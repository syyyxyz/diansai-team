# Keil uVision project STM32F407_FPGA_DDS.uvprojx, settings and files
target STM32F407_FPGA_DDS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_fpga_dds +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: __FPU_PRESENT=1U
  c misc: --gnu
  c include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407.sct
  group Startup
    ../Src/: startup_stm32f407_min.s system_stm32f407_min.c
  group Application
    ../Src/: main.c fpga_dds.c oled_ssd1306.c
  group Headers
    ../Inc/: fpga_dds.h stm32f407_min.h oled_ssd1306.h
